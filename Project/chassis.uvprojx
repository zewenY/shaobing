# Keil uVision project chassis.uvprojx, settings and files
target chassis (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: chassis +hex
  AfterMake: fromelf.exe --bin -o ./bin/infantry2.1.bin ./chassis/chassis.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;.\bsp;.\app;.\dmp
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: freertos.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_hal_timebase_TIM.c can.c dma.c gpio.c main.c spi.c tim.c
    ./bsp/: gimbal.c chassis.c kb.c
    ./app/: error_task.c sys.h
    ./: readme.txt
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Middlewares/FreeRTOS
    ../Src/: usart.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c queue.c tasks.c timers.c event_groups.c list.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_spi.c
  group bsp
    ./bsp/: bsp_can.c bsp_flash.c bt.c led.c pid.c mpu.c ahrs.c calibrate.c judge_sys.c forbidden.lib
software components: CMSIS:CORE 4.1.0
